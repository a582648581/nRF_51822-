# Keil uVision project leb_blinky.uvprojx, settings and files
target nRF51822_qfac (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: leb_blinky +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: NRF51822  BOARD_PCA10028 BSP_DEFINES_ONLY NRF51 SWI_DISABLE0
  c include: ..\..\..\components\libraries\util;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\uart;..\..\..\components\drivers_nrf\delay;..\..\..\components\boards;..\keil;..\..\..\..\Bare engineering template;..\..\..\components\drivers_nrf\timer;..\..\..\components\libraries\bsp;..\..\..\components\drivers_nrf\common
  asm define: NRF51822 BOARD_PCA10028 BSP_DEFINES_ONLY NRF51 SWI_DISABLE0
  asm include: ..\..\..\components\drivers_nrf\hal;..\..\..\components\libraries\log;..\..\..\components\libraries\log\src;..\..\..\components\libraries\util;..\..\..\components\libraries\uart;..\..\..\components\drivers_nrf\delay;..\..\..\components\drivers_nrf\hal;..\..\..\components\drivers_nrf\uart;..\..\..\components\boards;..\keil;..\..\..\components\drivers_nrf\nrf_soc_nosd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./: main.c sdk_config.h
  group nRF_Drivers
    ../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../components/drivers_nrf/hal/: nrf_adc.c
    ../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group board_def
    ../../../components/boards/: boards.c
  group nRF_Lib
    ../../../components/libraries/util/: app_error.c app_error_weak.c nrf_assert.c sdk_errors.c app_util_platform.c
    ../../../components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group Doc
    ../../../: README.md
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
